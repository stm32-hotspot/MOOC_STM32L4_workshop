<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LONGTERM_LOGGER_STANDBY_SRAM2.ewp</path>
  </project>
  <batchBuild />
</workspace>
